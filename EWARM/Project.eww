<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\stm32f405rgt6_detect_velocity.ewp</path>
  </project>
  <batchBuild />
</workspace>
